# Keil uVision project GD32F103C8T6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32F103C8T6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\CMSIS;..\LIB\Include;..\App;..\Driver\Include;..\Periphery\Include;..\Periphery;..\Driver;..\GD32F10x_usbd_library\usbd\Include;..\GD32F10x_usbd_library\device\Include;..\GD32F10x_usbd_library;..\GD32F10x_usbd_library\class\device\cdc\Include;..\GD32F10x_usbd_library\class\device\hid\Include;..\GD32F10x_usbd_library\class\device\winusb\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: startup_gd32f10x_md.s gd32f10x.h system_gd32f10x.c
  group APP
    ../App/: main.c gd32f10x_it.c
  group Periphery
    ../Periphery/Source/: psram.c
  group Driver
    ../Driver/: drv_config.h
    ../Driver/Source/: systick.c spi.c usart.c led.c exmc.c usbd.c key.c
  group LIB
    ../LIB/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group USB/USBD
    ../GD32F10x_usbd_library/: usbd_conf.h
    ../GD32F10x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USB/Device
    ../GD32F10x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USB/Class
    ../GD32F10x_usbd_library/class/device/cdc/Source/: cdc_acm_core.c
    ../GD32F10x_usbd_library/class/device/hid/Source/: standard_hid_core.c
    ../GD32F10x_usbd_library/class/device/winusb/Source/: standard_winusb_core.c
